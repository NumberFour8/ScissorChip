# IAR project MSP_MULT.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 2048
  General.GHeapSize2: 4096
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: C:\Users\E869439\Desktop\workspace_ccs\dl_5xx_6xx
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: keccak.c main.c msp_addsub.s43 msp_barrett.s43 msp_compress.c msp_cond.s43 msp_invert.c msp_keccak.s43 msp_keypair.c msp_ladder.c msp_mod16_25519.s43 msp_mod32_25519.s43 msp_montgomery.s43 msp_mul16_fios.s43 msp_mul32_cios.s43 msp_mul32_fios.s43 msp_mul32_karatsuba.s43 msp_mul32_sos.s43 msp_propagate.s43 msp_sign.c msp_step.c msp_utils.s43 sha512.c test.c
    ../dl_5xx_6xx/: msp_cpropp.s43 pmm.c ucs.c
